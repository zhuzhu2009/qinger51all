# Keil uVision project qinger51.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: qinger51 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\src;..\uip-1-0\uip;..\uip-1-0\unix
  link misc: REMOVEUNUSED
  group app
    ../src/: main.c
  group hw
    ../src/: 24c02.c beep.c DHT11.c iic.c key4x4.c NRF24L01.c oled.c PCF8563.c PWM.c serial_port.c spi.c enc28j60.c
  group util
    ../src/: delay.c
  group uipcore
    ../uip-1-0/uip/: psock.c timer.c uip.c uip_arp.c uip-fw.c uiplib.c uip-neighbor.c uip-split.c
  group uipport
    ../uip-1-0/unix/: clock-arch.c tapdev.c
